# Keil uVision project HT52352_Project.uvprojx, settings and files
target HT32F52352 (ARM-ADS)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.18
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x00001FDFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT52352_Project +hex
  AfterMake: fromelf --bin -o #L.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\Libraries\CMSIS\Include;..\Libraries\Device\Holtek\HT32F5xxxx\Include;..\Libraries\HT32F5xxxx_Driver\inc;..\Libraries\HT32_USBD_Library\inc;..\Source\Utilities;..\Source\Dev;..\Source\Main;..\Source\Dev\Ov7725;..\Source\Dev\Malloc;..\Source\Dev\SPI_SD_Card;..\Source\Dev\Fatfs\src;..\Source\Dev\Fatfs\src\option;..\Source\Dev\Picture;..\Source\Dev\Fatfs\exfuns;..\Source\Dev\bsp;..\Source\Dev\Appliction
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../Source/Main/: main.c ht32f5xxxx_01_it.c
    ../Source/Dev/: system.c
  group Startup
    ../Source/Main/: startup_ht32f5xxxx_01.s
  group CMSIS
    ../Source/Main/: system_ht32f5xxxx_01.c
  group Config
    ../Source/Main/: ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group FwLib
    ../Libraries/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c ht32_serial.c ht32_retarget.c
  group Malloc
    ../Source/Dev/Malloc/: malloc.c
  group Bsp
    ../Source/Dev/bsp/: bsp_18b20.c bsp_BFTM.c bsp_exti.c bsp_i2c.c bsp_spi.c bsp_uart.c bsp_SysTick.c
  group SD_Card
    ../Source/Dev/SPI_SD_Card/: SPI_MSD0_Driver.c
  group FatFs
    ../Source/Dev/Fatfs/src/: diskio.c ff.c
    ../Source/Dev/Fatfs/src/option/: ccsbcs.c
    ../Source/Dev/Fatfs/exfuns/: exfuns.c
  group Ov7725
    ../Source/Dev/Ov7725/: ov7725.c sccb.c
  group Picture
    ../Source/Dev/Picture/: bmp.c piclib.c
  group Utilities
    ../Source/Utilities/: ht32_board.c
  group Appliction
    ../Source/Dev/Appliction/: BMP280.c GPS.c GPRS.c
